Commit message: markers added

File: src/levitation_demo/urdf/levitation_robot.urdf (robot description, URDF)
Before this commit: robot robot, 19 links, 18 joints
Joints:
- joint camera_joint: origin xyz=0.11 0.0 -0.11 rpy=0.0 0.0 0.0 -> xyz=0.0 0.0 0.025 rpy=0.0 -1.5708 0.0
